# Remove policycoreutils-sestatus
RDEPENDS:${PN}:remove = "policycoreutils-sestatus"
