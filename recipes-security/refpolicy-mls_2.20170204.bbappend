require refpolicy-qti-common.inc

SRC_URI += "file://auto-sepolicy/patches/0001-policy-for-systemd-networkd.patch"
