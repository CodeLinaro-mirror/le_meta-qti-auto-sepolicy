require refpolicy-qti-common.inc

SRC_URI:remove:sa510m = "file://${BASEMACHINE}/"
SRC_URI:remove:sa510m = "file://auto-sepolicy/${MACHINE}/"
